# Keil uVision project lab3.uvprojx, settings and files
target EK-TM4C1294XL (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_5_06v7)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab3 +hex
  AfterMake: fromelf.exe --bin Objects\lab3.axf --output Objects\lab3.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99
  c include: ..\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Documentation
    ./: readme.txt
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group Source
    ./: globals.h main.c startup_rvmdk.S lcd.c lcd.h sys_tick.c sys_tick.h gpio.c gpio.h clock.c clock.h keyboard.c keyboard.h
software components: CMSIS:CORE 6.0.0
